Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_3/temp/tmp_4424_318_SpnlR/format_2/913606000001(architecture=350).ifc
Time: 2024-02-15T12:35:20
Made in: PARTsolutions

# IfcProject, 913606000001(architecture=350)
Description: CAYONO Aufsatz-Waschtisch

# IfcDiscreteAccessory, 913606000001(architecture=350)
In: BUILDING
Description: 913606000001(architecture=350)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 913606000001
ePset_PARTsolutions - NB: 913606000001(architecture=350); NN: 3189; NT: CAYONO - Countertop washbasins; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: 913606000001(architecture=350); CATALOG: Kaldewei; MNR: 3189; A: 913606000001; LODLEVEL: 350; B: parts/3189.png; C: CAYONO - Countertop washbasins; D: 10.3; E: KALDEWEI; F: 4055761222181; G: 910500010999 (Modell 3915); H: not applicable; I: https://www.kaldewei.de/fileadmin/data/sprachen/alle/pdfs/leistungserkla__rungBW-DW-WT-0216Web.pdf; J: all countrys; K: ISO 14025, EN 15804; L: 30; M: Furnishing Element; N: IfcSanitaryTerminalType; O: SS-35-65-70-94; P: Wash Basin Systems; Q: 23-31-13-11; R: RVT_METRICPLUMBINGFIXTURE; S: EC011550; EF002169: steel enamel; EF000051: Shape E; EF000007: alpine white; EF000003: Built-in; EF002442: blade mounting; EF000049: 415; EF004567: 580; EF000040: 173; NORM: CE certificate; etim7_EC011550: EC011550; etim7_EC011550_FORM: Rectangular; etim7_EC011550_MONTAGEART: Built-in
